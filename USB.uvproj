# Keil uVision project USB.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH554 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: Output +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  group User
    ./User/: DataFlash.C Debug.C GPIO.C Main.C USBbase.C
